!Keysight Technologies,N5245B,MY57181321,A.14.80.03
!Date: Thursday, August 24, 2023 17:59:16
!Correction: S11(C  2-Port  )
!S21(C  2-Port  )
!S12(C  2-Port  )
!S22(C  2-Port  )
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -50.69 dB at 35.89 GHz (marker M1); lowest = -105.1 dB at 4.83 GHz (marker M2)
!   lowest |S11| = -38.4 dB at 14.84 GHz (marker M3), VSWR 1.02, Z = 48.9 - j0.383 ohm
!   |S11| at or under -10 dB: 12.44 GHz to 15.83 GHz (3.398 GHz wide, 24 % of centre); 17.55 GHz to 17.89 GHz (341 MHz wide, 1.92 % of centre); 22.11 GHz to 23.15 GHz (1.036 GHz wide, 4.58 % of centre) (the widest 3 of 4)
!   |S22| runs from -8.8 to 1.7 dB; largest |S21 - S12| = 0.0027
!   the Smith chart shows 10.6 GHz to 22.25 GHz only
!   S11 on the Smith chart (normalised r, x): 10.6 GHz: 1.09, -1.92; 11.92 GHz: 0.46, -0.47; 13.06 GHz: 0.90, +0.46; 15.01 GHz: 0.97, +0.09; 17.62 GHz: 1.21, -0.70; 22.25 GHz: 0.76, -0.41
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.3  -54.7  -60.5  -0.3
! 1.06 GHz  -0.2  -76.4  -81.7  -0.2
! 4.83 GHz  -0.4  -105.1  -80.7  -0.3
! 6.68 GHz  -3.2  -78.7  -78.9  -0.4
! 10.6 GHz  -3.4  -78.4  -80.0  -1.3
! 11.92 GHz  -6.7  -76.3  -83.9  -2.4
! 13.06 GHz  -12.3  -76.6  -82.4  -5.1
! 13.34 GHz  -13.5  -77.7  -80.2  -5.6
! 14.26 GHz  -12.8  -80.7  -78.6  -8.3
! 14.84 GHz  -38.4  -73.1  -89.1  -6.5
! 15.01 GHz  -26.3  -79.5  -75.6  -6.6
! 16.03 GHz  -8.1  -78.6  -82.9  -3.6
! 17.62 GHz  -10.1  -70.0  -73.4  -3.0
! 20.01 GHz  -7.1  -78.9  -79.7  -3.7
! 22.25 GHz  -11.6  -72.8  -67.3  -4.0
! 26.67 GHz  -1.1  -66.5  -63.2  -3.8
! 33.34 GHz  -0.2  -71.8  -68.0  -0.4
! 35.17 GHz  0.6  -68.3  -74.3  0.1
! 35.89 GHz  -1.4  -50.7  -52.3  -1.1
! 36.71 GHz  1.4  -72.7  -70.5  0.5
! 37.7 GHz  -3.8  -58.6  -65.2  -0.2
! 40 GHz  -0.9  -65.5  -61.6  1.7
