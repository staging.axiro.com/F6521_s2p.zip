!Keysight Technologies,N5245B,MY57181321,A.14.80.03
!Date: Thursday, August 24, 2023 17:09:32
!Correction: S11(C  2-Port  )
!S21(C  2-Port  )
!S12(C  2-Port  )
!S22(C  2-Port  )
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -54.22 dB at 35.78 GHz (marker M1); lowest = -107.6 dB at 1.38 GHz (marker M2)
!   lowest |S11| = -35.7 dB at 14.87 GHz (marker M3), VSWR 1.03, Z = 51.5 - j0.699 ohm
!   |S11| at or under -10 dB: 12.07 GHz to 16.19 GHz (4.121 GHz wide, 29.2 % of centre); 16.41 GHz to 18.02 GHz (1.608 GHz wide, 9.34 % of centre); 21.81 GHz to 23.11 GHz (1.295 GHz wide, 5.76 % of centre) (the widest 3 of 6)
!   |S22| runs from -10.6 to -0.2 dB; largest |S21 - S12| = 0.0018
!   the Smith chart shows 9.61 GHz to 24.01 GHz only
!   S11 on the Smith chart (normalised r, x): 9.61 GHz: 3.46, +1.02; 11.2 GHz: 0.78, -1.16; 12.52 GHz: 0.65, +0.02; 14.97 GHz: 1.05, +0.03; 19.09 GHz: 1.36, -0.85; 24.01 GHz: 1.12, -1.19
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.4  -62.2  -57.0  -0.3
! 240 MHz  -0.5  -77.4  -80.3  -0.4
! 1.38 GHz  -0.5  -107.6  -95.4  -0.4
! 6.68 GHz  -3.6  -83.9  -83.8  -0.8
! 9.61 GHz  -4.7  -66.7  -74.9  -1.0
! 11.2 GHz  -5.1  -75.6  -79.3  -2.2
! 12.52 GHz  -13.3  -76.3  -77.1  -4.4
! 13.34 GHz  -15.3  -71.3  -80.2  -7.4
! 14.87 GHz  -35.7  -94.0  -81.3  -7.7
! 14.97 GHz  -31.0  -81.4  -80.1  -7.6
! 15.93 GHz  -10.8  -83.5  -82.5  -5.0
! 19.09 GHz  -8.7  -85.3  -79.7  -4.6
! 20.01 GHz  -7.8  -82.7  -75.1  -5.2
! 22.66 GHz  -12.8  -72.8  -72.5  -6.2
! 24.01 GHz  -6.1  -72.7  -67.7  -6.2
! 26.67 GHz  -2.9  -73.3  -65.5  -5.6
! 33.34 GHz  -1.6  -78.2  -89.7  -1.9
! 35.06 GHz  -0.9  -61.8  -68.6  -1.6
! 35.78 GHz  -4.0  -54.2  -55.2  -2.9
! 36.61 GHz  -0.9  -72.2  -62.0  -1.8
! 37.88 GHz  -5.6  -63.8  -66.7  -2.3
! 40 GHz  -3.9  -65.9  -69.4  -0.5
