!Keysight Technologies,N5245B,MY57181321,A.14.80.03
!Date: Thursday, August 24, 2023 18:37:06
!Correction: S11(C  2-Port  )
!S21(C  2-Port  )
!S12(C  2-Port  )
!S22(C  2-Port  )
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  RI  R 50
! Worked out from all points (one-way two-port):
!   4000 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -53.32 dB at 35.93 GHz (marker M1); lowest = -116.9 dB at 29.8 GHz (marker M2)
!   lowest |S11| = -29.3 dB at 14.83 GHz (marker M3), VSWR 1.07, Z = 52.9 - j2.02 ohm
!   |S11| at or under -10 dB: 11.88 GHz to 18.05 GHz (6.165 GHz wide, 41.2 % of centre); 18.85 GHz to 18.98 GHz (139.6 MHz wide, 0.738 % of centre); 21.62 GHz to 23.05 GHz (1.425 GHz wide, 6.38 % of centre)
!   |S22| runs from -11.7 to -0.4 dB; largest |S21 - S12| = 0.0016
!   the Smith chart shows 8.79 GHz to 24.93 GHz only
!   S11 on the Smith chart (normalised r, x): 8.79 GHz: 1.74, +0.58; 10.67 GHz: 1.66, -1.52; 12.22 GHz: 0.66, -0.21; 14.99 GHz: 1.11, +0.02; 19.83 GHz: 1.51, -0.92; 24.93 GHz: 1.04, -1.33
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -0.5  -63.7  -77.7  -0.4
! 1.19 GHz  -0.6  -80.8  -81.2  -0.5
! 6.68 GHz  -3.8  -92.1  -84.7  -0.9
! 8.79 GHz  -9.5  -75.4  -74.9  -1.7
! 9.47 GHz  -5.5  -65.4  -69.5  -1.4
! 10.67 GHz  -5.3  -86.8  -79.9  -2.5
! 12.22 GHz  -12.5  -73.7  -89.8  -4.5
! 13.34 GHz  -15.8  -75.9  -79.9  -8.6
! 14.83 GHz  -29.3  -79.8  -78.8  -8.4
! 14.99 GHz  -25.7  -80.1  -78.2  -8.1
! 15.79 GHz  -12.3  -85.4  -88.2  -6.1
! 19.83 GHz  -8.1  -70.4  -73.1  -6.2
! 20.01 GHz  -8.1  -72.3  -87.1  -6.0
! 24.93 GHz  -5.3  -66.3  -64.5  -6.1
! 25.69 GHz  -3.6  -85.6  -89.6  -7.3
! 26.67 GHz  -3.8  -67.8  -72.4  -6.3
! 29.8 GHz  -2.5  -116.9  -64.1  -5.0
! 33.34 GHz  -2.1  -79.7  -75.9  -2.5
! 35.93 GHz  -4.5  -53.3  -54.5  -3.5
! 36.66 GHz  -2.5  -84.7  -76.5  -3.1
! 37.61 GHz  -6.4  -60.2  -55.8  -2.0
! 40 GHz  -5.7  -76.1  -73.4  -1.4
